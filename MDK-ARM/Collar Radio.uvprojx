# Keil uVision project Collar Radio.uvprojx, settings and files
target Collar Radio (6220000::V6.22::ARMCLANG)
  device: STM32G070KBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Collar Radio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G070xx,USE_HAL_DRIVER,CMSIS_device_header=<stm32g0xx.h>,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/OLED;../Drivers/SC7A20;../Drivers/RDA5807M;../Drivers/BMP180;../Drivers/u8g2;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../Application;../Application/MiaoUI;../Application/MiaoUI/core;../Application/MiaoUI/display;../Application/MiaoUI/fonts;../Application/MiaoUI/widget;../Application/MiaoUI/indev;../Application/MiaoUI/images;../Drivers/Buttons;../Application/Applications;../Application/Tasks;../Application/Algorithms
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c i2c.c rtc.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group U8g2
    ../Drivers/u8g2/: u8g2_d_memory.c u8g2_d_setup.c u8x8_d_ssd1306_128x64_noname.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Drivers
    ../Drivers/OLED/: oled.c
    ../Drivers/Buttons/: buttons.c
    ../Drivers/BMP180/: bmp180.c
    ../Drivers/RDA5807M/: rda5807m.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Applications
    ../Application/Applications/: radio.c game_snake.c notifications_draw.c burn_in_tester.c i2c_scanner.c
  group MiaoUI
    ../Application/MiaoUI/display/: dispDriver.c
    ../Application/MiaoUI/core/: ui.c
    ../Application/MiaoUI/fonts/: fonts.c
    ../Application/MiaoUI/indev/: indevDriver.c
    ../Application/MiaoUI/widget/: parameter.c text.c wave.c
    ../Application/MiaoUI/images/: image.c
    ../Application/MiaoUI/: ui_conf.c
  group Tasks
    ../Application/Tasks/: adc_handle.c bmp180_handle.c button_handle.c menu.c sys_shutdown.c notifications.c
  group Algorithms
    ../Application/Algorithms/: time.c radio_operation.c system_statistic.c system_operation.c display_effects.c
software components: CMSIS:CORE 6.1.0
